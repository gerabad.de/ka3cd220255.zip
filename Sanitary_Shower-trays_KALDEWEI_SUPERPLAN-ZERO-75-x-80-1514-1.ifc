Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Shower-trays_KALDEWEI_SUPERPLAN-ZERO-75-x-80-1514-1.ifc
Time: 2021-09-20T15:00:07
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, SUPERPLAN ZERO 75 x 80 1514-1
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): SUPERPLAN ZERO 75 x 80 1514-1; SKU (BO_prodsku): SUPERPLAN_ZERO_75_x_80_1514-1; ManufacturName (BO_Manufac): KALDEWEI; BrandUrl (BO_brandurl): https://www.kaldewei.com; ProductFamily (BO_prodfam): SUPERPLAN ZERO; ProductGroup (BO_prodgroup): SUPERPLAN ZERO; ManufacturCountry (BO_mancont): Germany; DesignCountry (BO_designcont): Germany; PublishDate (BO_publisdat): 9/9/2021; EditionNumber (BO_edinum): 3; Width (BO_width): 800; Height (BO_height): 20; Depth (BO_depth): 750; Weight (BO_weight): 15.9; QR (BO_boqrurl): http://bimobject.com/kaldewei/product/SUPERPLAN_ZERO_75_x_80_1514-1; ProductDataUrl (BO_prodaturl): bimobject.com/kaldewei/product/SUPERPLAN_ZERO_75_x_80_1514-1; GtinCode (BO_gtin): 4055761248761; MaterialMain (BO_mainmat): Steel; MaterialSecondary (BO_secmat): Enamel; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Shower trays; BimObjectCategoryCode (BO_bocat_code): shower-trays; IfcClassification (BO_ifcclas): Furnishing Element; UnspscCode (BO_unspsc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L72143; Uniclass14Description (BO_uniclass_1_4_desc): Shower trays; Uniclass20Code (BO_uniclass_2_0_code): PR-35-06-84; Uniclass20Description (BO_uniclass_2_0_desc): Shower Trays; NBSReference (BO_nbs_ref): 35-06-84; NBSReferenceDescription (BO_nbs_desc): Shower Trays; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
